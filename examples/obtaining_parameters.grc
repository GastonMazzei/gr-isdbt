options:
  parameters:
    author: flarroca
    generate_options: qt_gui
    id: obtaining_the_parameters
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: active_carriers
  id: variable
  parameters:
    value: 13*108*2**(mode-1)+1
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    label: center frequency
    type: real
    value: '593143000'
  states: {}
- name: data_carriers
  id: variable
  parameters:
    value: 13*96*2**(mode-1)
  states: {}
- name: guard
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,1
    label: Guard Interval
    label0: 1/4
    label1: 1/8
    label2: 1/16
    label3: 1/32
    num_opts: '4'
    option0: 1/4.0
    option1: 1/8.0
    option2: 1/16.0
    option3: 1/32.0
    orient: Qt.QHBoxLayout
    type: real
    value: 1/4
    widget: radio_buttons
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Mode
    label0: Mode 3 (8K)
    label1: Mode 2 (4K)
    label2: Mode 1 (2K)
    num_opts: '3'
    option0: '3'
    option1: '2'
    option2: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '3'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6*64/63
  states: {}
- name: total_carriers
  id: variable
  parameters:
    value: 2**(mode+10)
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: active_carriers
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: total_carriers
    type: complex
  states: {}
- name: blocks_file_source_1_0
  id: blocks_file_source
  parameters:
    file: /home/radarg/Documents/ISDBT/usrp_samples.dat
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(guard*total_carriers)
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: data_carriers
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: 13*108*2**(mode-1)+1
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '8192'
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: active_carriers
    type: float
  states: {}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: 13*108*2**(mode-1)+1
    type: complex
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '6000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    manual_gain1: '40'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '8126984'
    type: fc32
    uri: '"ip:11.1.2.105"'
  states: {state: disabled}
- name: isdbt_ofdm_synchronization_0
  id: isdbt_ofdm_synchronization
  parameters:
    cp_length: '0.250'
    interpolate: 'False'
    mode: '3'
  states: {}
- name: isdbt_tmcc_decoder_0
  id: isdbt_tmcc_decoder
  parameters:
    mode: '3'
    print_params: 'False'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6e6/2.0
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'FIRST: Try different values of mode and guard until you see a clear peak '
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: 'SECOND: Configure the OFDM synchronization with the guard and mode you obtained before to get the rest of the parameters.'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: (6.4e6*80/63 ) / 6e6
    type: ccf
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: 13*108*2**(mode-1)+1
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"freq corr"'
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 2,0,5,1
    name: '"Autocorrelation with a delay of total_carriers"'
    size: int(2*(1)*(total_carriers))
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    label1: ''
    name: '"Channel gain (frequency, disregard the x-axis label)"'
    size: active_carriers
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '5600000'
    center_freq0: center_freq
    clock_rate: '0.0'
    clock_source0: external
    gain0: '14'
    otw: sc8
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_file_source_1_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_1_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_mag_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_2, '0', qtgui_const_sink_x_0, '0']
- [iio_pluto_source_0, '0', blocks_throttle_0, '0']
- [isdbt_ofdm_synchronization_0, '0', blocks_null_sink_0_0, '0']
- [isdbt_ofdm_synchronization_0, '0', blocks_vector_to_stream_0_2, '0']
- [isdbt_ofdm_synchronization_0, '0', isdbt_tmcc_decoder_0, '0']
- [isdbt_ofdm_synchronization_0, '1', blocks_complex_to_mag_0, '0']
- [isdbt_ofdm_synchronization_0, '2', blocks_null_sink_0_1, '0']
- [isdbt_ofdm_synchronization_0, '2', qtgui_number_sink_0, '0']
- [isdbt_ofdm_synchronization_0, '3', blocks_null_sink_0_2, '0']
- [isdbt_ofdm_synchronization_0, '4', blocks_null_sink_0_0_0, '0']
- [isdbt_tmcc_decoder_0, '0', blocks_null_sink_0, '0']
- [low_pass_filter_0, '0', blocks_delay_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [low_pass_filter_0, '0', isdbt_ofdm_synchronization_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_throttle_0, '0']
- [pfb_arb_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', pfb_arb_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
