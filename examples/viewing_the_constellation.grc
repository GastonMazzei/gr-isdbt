options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: viewing_the_constellation
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: active_carriers
  id: variable
  parameters:
    value: 13*108*2**(mode-1)+1
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    label: Center freq.
    type: int
    value: '593143000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.14'
  states: {}
- name: guard
  id: variable
  parameters:
    value: 1.0/16
  states: {}
- name: mode
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6.4e6*80/63
  states: {}
- name: total_carriers
  id: variable
  parameters:
    value: 2**(10+mode)
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: active_carriers
  states: {state: disabled}
- name: blocks_file_source_1_0
  id: blocks_file_source
  parameters:
    file: /home/radarg/Documents/ISDBT/usrp_samples.dat
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '8192'
  states: {state: disabled}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: active_carriers
  states: {}
- name: blocks_null_sink_0_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: active_carriers
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: active_carriers
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: active_carriers
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: active_carriers
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_2_0
  id: blocks_vector_to_stream
  parameters:
    num_items: total_carriers
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_2_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: total_carriers
    type: complex
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: active_carriers
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(active_carriers)
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '6000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    manual_gain1: '40'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '8126984'
    type: fc32
    uri: '"ip:11.1.2.105"'
  states: {state: disabled}
- name: isdbt_ofdm_synchronization_0
  id: isdbt_ofdm_synchronization
  parameters:
    cp_length: '0.250'
    interpolate: 'False'
    mode: '3'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5.6e6/2.0
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: window.WIN_HAMMING
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: (6.4e6*80/63 ) / 8e6
    type: ccf
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab@1
    size: 2*active_carriers
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: tab@1
    name: '"fft bin port"'
    size: 2*total_carriers
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    label1: '"Raw Freq Corrected"'
    label2: '"Equalized Freq Corrected NonCropped"'
    name: '"freq corrected with only active carriers"'
    nconnections: '2'
    norm_window: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    gui_hint: tab@0
    name: '"Incoming spectrum"'
    norm_window: 'True'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"freq corr"'
    type: float
    update_time: '0.05'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: tab@2
    label1: ''
    name: '"Channel gain (frequency, disregard the x-axis label)"'
    size: active_carriers
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: tab@2
    label1: ''
    label2: ''
    name: '"Channel taps"'
    size: active_carriers
    srate: samp_rate*active_carriers/total_carriers
    type: complex
  states: {state: disabled}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Spectrum
    label1: Constellation
    label2: Estimated channel
    num_tabs: '3'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '5600000'
    center_freq0: center_freq
    clock_rate: '0.0'
    clock_source0: external
    dev_args: '""'
    gain0: '20'
    otw: sc8
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_file_source_1_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_1_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_file_source_1_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_2, '0', qtgui_const_sink_x_0, '0']
- [blocks_vector_to_stream_0_2, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_stream_0_2_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_stream_0_2_0_0, '0', qtgui_freq_sink_x_0, '1']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [isdbt_ofdm_synchronization_0, '0', blocks_null_sink_0_0_0_0, '0']
- [isdbt_ofdm_synchronization_0, '0', blocks_vector_to_stream_0_2, '0']
- [isdbt_ofdm_synchronization_0, '1', blocks_complex_to_mag_0, '0']
- [isdbt_ofdm_synchronization_0, '1', blocks_null_sink_0_0_0_0_0, '0']
- [isdbt_ofdm_synchronization_0, '1', fft_vxx_0_0, '0']
- [isdbt_ofdm_synchronization_0, '2', blocks_null_sink_0, '0']
- [isdbt_ofdm_synchronization_0, '2', qtgui_number_sink_0, '0']
- [isdbt_ofdm_synchronization_0, '3', blocks_null_sink_0_0, '0']
- [isdbt_ofdm_synchronization_0, '4', blocks_null_sink_0_0_0, '0']
- [isdbt_ofdm_synchronization_0, '4', blocks_vector_to_stream_0_2_0, '0']
- [isdbt_ofdm_synchronization_0, '5', blocks_vector_to_stream_0_2_0_0, '0']
- [low_pass_filter_0, '0', isdbt_ofdm_synchronization_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_throttle_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
